RDEPENDS_${PN}-cairo += "libgles2-mali"

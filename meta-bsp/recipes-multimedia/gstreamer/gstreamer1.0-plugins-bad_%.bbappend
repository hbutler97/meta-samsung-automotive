RDEPENDS_${PN}-opengl += "libegl-mali"
RDEPENDS_libgstgl-1.0 += "libegl-mali"


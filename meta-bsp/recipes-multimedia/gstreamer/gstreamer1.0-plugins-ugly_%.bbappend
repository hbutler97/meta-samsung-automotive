RDEPENDS_${PN}-pango += "libgles2-mali"

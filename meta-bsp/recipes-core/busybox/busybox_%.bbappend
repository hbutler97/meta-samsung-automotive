FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI .= 'file://sec_custom_defconfig.cfg'

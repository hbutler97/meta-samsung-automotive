require mali-userspace.inc

TYPE = "mali-t62x"

SRC_URI = "\
    file://libmali.so \
    file://libmali-gbm.so \
"


LICENSE = "Proprietary"
